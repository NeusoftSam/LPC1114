# Keil uVision project LPC1114.uvprojx, settings and files
target LPC1114 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1114 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group USER
    ../src/: main.c
  group GPIO
    ../src/: gpio.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
